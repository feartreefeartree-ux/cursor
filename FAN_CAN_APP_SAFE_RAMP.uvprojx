# Keil uVision project FAN_CAN_APP_SAFE_RAMP.uvprojx, settings and files
target FAN_CAN_APP_SAFE_RAMP (6220000::V6.22::ARMCLANG)
  device: S32K144WAxxxLFx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: FAN_CAN_APP_SAFE_RAMP +hex
  AfterMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ".\tools\build_universal_from_keil.ps1"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CPU_S32K144W,FAN_CAN_APP_SAFE_RAMP,START_FROM_FLASH,DISABLE_WDOG=1
  c misc: -Oz -Wall -Wextra
  c include: .\inc;.\config;.\RTE\Device\S32K144W;$$Device:S32K144WAxxxLFx$platform\devices;$$Device:S32K144WAxxxLFx$platform\devices\S32K144W\include;..\..\DEPENDENCIES\CMSIS\6.1.0\CMSIS\Core\Include
  asm define: START_FROM_FLASH
  asm misc: --cpreproc
  asm include: .\config
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\linker\FanCanAppTest.sct
  link misc: --map --list=FAN_CAN_APP_SAFE_RAMP.map --symbols --xref --info=summarysizes
  group Entry
    ./src/: main.c
  group Application_Interface
    ./src/app_if/: FanCan_AppIf.c FanBootApp_Handover.c
    ./src/application/: FanLogic_App.c FanAdcPwm_AppExample.c
  group CAN
    ./src/can/: FanCan_Codec.c FanCan_Driver.c
  group Platform
    ./src/platform/: FanCan_Platform.c FanAdcPwm_HwExample.c
    ./RTE/Device/S32K144W/: startup.c system_S32K144W.c startup_S32K144W.s
  group Configuration
    ./inc/: FanCan_AppIf.h FanCan_AppSignals.h FanCan_Codec.h FanCan_Driver.h FanBootApp_Handover.h BootApp_SharedMailbox.h FanCan_Platform.h FanCan_Types.h FanLogic_App.h FanAdcPwm_App.h FanAdcPwm_HwIf.h
    ./config/: FanCan_BoardConfig.h FanAdcPwm_ExampleConfig.h FanCan_ProtocolConfig.h
